# Keil uVision project Key-M.uvproj, settings and files
target Key-M (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Key-M +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Sys;..\User
  group User
    ./: STARTUP.A51 main.c
  group Diver
    ../Driver/: Beer.c init.c LDE.c Relay.c SEG.c timer.c key.c
  group Sys
    ../Sys/: Delay.c
