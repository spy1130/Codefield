# Keil uVision project TIM-PRO-M.uvproj, settings and files
target TIM-PRO-M (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TIM-PRO-M +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Sys;..\User
  group User
    ./: main.c
  group Sys
    ../Sys/: Delay.c
  group Driver
    ../Driver/: Beer.c init.c key.c LDE.c Relay.c SEG.c timer.c
