# Keil uVision project INT.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: INT
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: main.c
