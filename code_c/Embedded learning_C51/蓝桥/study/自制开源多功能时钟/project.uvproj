# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c
  group Sys
    ./: timer.h timer.c
  group Driver
    ./: bsp_seg.c bsp_seg.h bsp_key.c bsp_key.h bsp_led.c bsp_led.h init.c init.h ds1302.c ds1302.h onewire.c onewire.h
