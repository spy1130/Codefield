# Keil uVision project first.uvproj, settings and files
target first (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: first +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: init.c Key.c Led.c Seg.c ds1302.c iic.c onewire.c
