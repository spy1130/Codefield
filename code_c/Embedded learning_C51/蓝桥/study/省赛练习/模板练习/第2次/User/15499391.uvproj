# Keil uVision project 15499391.uvproj, settings and files
target 15499391 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 15499391 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c STARTUP.A51
  group Driver
    ../Driver/: Key.c Led.c Seg.c init.c ds1302.c iic.c onewire.c
