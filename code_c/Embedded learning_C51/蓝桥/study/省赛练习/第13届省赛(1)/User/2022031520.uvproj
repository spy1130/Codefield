# Keil uVision project 2022031520.uvproj, settings and files
target 2022031520 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2022031520 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Init.c Key.c Led.c Seg.c
    ../../第6届省赛/Driver/: ds1302.c onewire.c
