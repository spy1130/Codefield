# Keil uVision project LED-M.uvproj, settings and files
target LED-M (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LED-M +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Sys;..\User
  group User
    ./: STARTUP.A51 main.c
  group Sys
    ../Sys/: Delay.c
  group Driver
    ../Driver/: LDE.c init.c init.h
