# Keil uVision project INT-M.uvproj, settings and files
target INT-M (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: INT-M +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Sys;..\Driver
  group User
    ./: main.c
  group Sys
    ../Sys/: Delay.c INT.c
  group Driver
    ../Driver/: init.c LDE.c key.c timer.c
