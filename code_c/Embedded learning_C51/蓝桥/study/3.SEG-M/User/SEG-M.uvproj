# Keil uVision project SEG-M.uvproj, settings and files
target SEG=M (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SEG-M +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Sys;..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: Beer.c init.c LDE.c Relay.c SEG.c STDIO.H STRING.H
  group Sys
    ../Sys/: Delay.c
