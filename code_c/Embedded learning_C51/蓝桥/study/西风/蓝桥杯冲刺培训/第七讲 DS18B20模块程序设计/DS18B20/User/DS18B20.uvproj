# Keil uVision project DS18B20.uvproj, settings and files
target DS18B20 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Init.c Key.c Led.c Seg.c onewire.c
