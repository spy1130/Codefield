# Keil uVision project Xifeng.uvproj, settings and files
target Xifeng (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Xifeng +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: ds1302.c iic.c Init.c Key.c Led.c onewire.c Seg.c
