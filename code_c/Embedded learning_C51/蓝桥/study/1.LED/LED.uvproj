# Keil uVision project LED.uvproj, settings and files
target LED (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: main.c
    ../: STC15F2K60S2.H
