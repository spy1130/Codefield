# Keil uVision project IAP15.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IAP15 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: EEPROM_AT24C02 PCF8591_DAC
  c include: ..\Driver
  group Source Group 1
    ./: main.c
    ../Driver/: tim.c seg.c key.c iic.c ultrasonic.c
