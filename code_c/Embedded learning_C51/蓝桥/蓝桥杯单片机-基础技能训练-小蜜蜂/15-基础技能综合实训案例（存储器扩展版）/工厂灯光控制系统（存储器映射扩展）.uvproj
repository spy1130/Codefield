# Keil uVision project 工厂灯光控制系统（存储器映射扩展）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 工厂灯光控制系统（存储器映射扩展） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 工厂灯光控制系统(存储器版).c
