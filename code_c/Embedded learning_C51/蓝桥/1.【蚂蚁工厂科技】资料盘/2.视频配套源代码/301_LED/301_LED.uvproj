# Keil uVision project 301_LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 301_LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Sys
  group User
    ./: main.c
  group Sys
    ../Sys/: delay.c
  group Driver
    ../Driver/: bsp_led.c bsp_init.c
